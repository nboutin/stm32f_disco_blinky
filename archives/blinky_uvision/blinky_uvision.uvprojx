# Keil uVision project blinky_uvision.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky_uvision
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.cpp
software components: CMSIS:CORE 5.6.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:Startup 2.6.3
